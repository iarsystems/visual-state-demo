# IAR project VisualStateDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe177
  ICCARM.CCIncludePath2: Inc; ../VS_Coder
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/C-SPY Macros
    Src/: cspy.mac
  group Application/Source Files
    Src/: actionFunctions.c main.c simpleEventHandler.c
  group VS_Coder/Header Files
    ../VS_coder/: CSpyLink.h System1.h Workspace.h
  group VS_Coder/Source Files
    ../VS_coder/: CSpyLink.c System1.c Workspace.c
